## uwvg/Kconfig
```kconfig
menuconfig UWVG
	bool "Under Water Vechile Group"

if UWVG

source "uwvg/uwvg_gpio_drv/Kconfig"

endif
```
